LOAD_ROM_1  0x000000 0x3000
{
	APROM_Bootloader.bin  0x000000 0x3000
	{
		startup_NUC131.o (RESET, +FIRST)
        .ANY (+RO)
	}
	
	SRAM  0x20000000 0x2000
	{
		* (+RW, +ZI)
	}
}

