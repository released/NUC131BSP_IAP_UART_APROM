LOAD_ROM_1  0x003000 0xD000
{
	APROM_application.bin  0x003000 0xD000
	{
		startup_NUC131.o (RESET, +FIRST)
        .ANY (+RO)
	}
	
	SRAM  0x20000000 0x2000
	{
		* (+RW, +ZI)
	}
}

